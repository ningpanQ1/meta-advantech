SRC_URI_remove = "file://0007-MLK-23858-profiles-audio-increased-the-MTU-size-to-M.patch"
