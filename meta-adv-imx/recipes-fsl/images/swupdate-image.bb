SUMMARY = "Root filesystem for swupdate as rescue system"
DESCRIPTION = "Root FS to start swupdate in rescue mode	\
		"
LICENSE = "MIT"

require swupdate-initramfs.inc
