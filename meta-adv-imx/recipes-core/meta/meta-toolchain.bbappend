DESCRIPTION = "Advantech toolchain feature"

require recipes-core/meta/adv-sdk.inc
