OS_RELEASE_FIELDS_append = " IMAGE_VERSION"
IMAGE_RELEASE_VERSION ?= "eamb9918-sdcard_0.7.1"
IMAGE_VERSION = "${IMAGE_RELEASE_VERSION}"
