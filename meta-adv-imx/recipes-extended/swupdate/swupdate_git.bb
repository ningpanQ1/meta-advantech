require swupdate.inc

DEFAULT_PREFERENCE = "-1"

SRCREV = "04a7f4dae444103fa7bce14f47c80e876095cc04"
PV = "2021.04+git${SRCPV}"
