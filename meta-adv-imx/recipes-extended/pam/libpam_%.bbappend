RDEPENDS_${PN}-runtime_append += " \
				  ${MLPREFIX}pam-plugin-cracklib-${libpam_suffix} \
				"
