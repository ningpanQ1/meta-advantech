DESCRIPTION = "Advantech QT5 toolchain feature"

require recipes-core/meta/adv-sdk.inc
