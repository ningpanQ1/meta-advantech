# enable qt sqlite driver for falkon browser
PACKAGECONFIG_append = " sql-sqlite"
