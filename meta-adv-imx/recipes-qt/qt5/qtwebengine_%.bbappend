# enable proprietary codecs for falkon browser (qtwebengine)
PACKAGECONFIG_append = " proprietary-codecs"
