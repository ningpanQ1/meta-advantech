SRC_URI = "git://github.com/Advantech-IIoT/uboot-imx.git;branch=imx_v2020.04_5.4.70_2.3.0;protocol=https"
SRCREV = "8cea63b8c042006b3e8e2737d5593c5bb60c4bf7"
