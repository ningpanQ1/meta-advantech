SRCBRANCH = "lf-5.10.y"
LOCALVERSION = "-lts-5.10.y"
KERNEL_SRC = "git://github.com/Advantech-IIoT/linux-imx.git;protocol=https"
SRCREV = "1f5a16054736b31453953ab5ecfb138b41830af4"
