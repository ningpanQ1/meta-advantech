SRCBRANCH = "imx_5.4.70_2.3.0"
LOCALVERSION = "-2.3.0"
KERNEL_SRC = "git://github.com/Advantech-IIoT/linux-imx.git;protocol=https"
SRCREV = "9d93453314231f6bb1746bbec6cdbbfc26efbad7"
