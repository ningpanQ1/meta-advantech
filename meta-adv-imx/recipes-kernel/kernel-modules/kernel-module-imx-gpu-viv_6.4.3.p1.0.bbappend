SRCBRANCH = "imx_5.4.70_2.3.0"
LOCALVERSION = "-2.3.0"
KERNEL_SRC ?= "git://github.com/Advantech-IIoT/linux-imx.git;protocol=https"

SRCREV = "25b077b6e3b78519ae6eeb2b54c6694650fd76b4"
